# Keil uVision project hiku_stm32_fw.uvprojx, settings and files
target hiku_stm32_fw (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: hiku_stm32_fw +hex
  AfterMake: C:\Users\user\Documents\Hiku\hiku_stm32_fw\hiku_stm32_fw.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER,USE_STM320308_DISCO,
  c misc: --C99
  c include: .\Inc;..\STM32Cube_FW_F0_V1.2.0\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\STM32Cube_FW_F0_V1.2.0\Drivers\STM32F0xx_HAL_Driver\Inc;..\STM32Cube_FW_F0_V1.2.0\Drivers\BSP\STM32F0308-Discovery;..\STM32Cube_FW_F0_V1.2.0\Drivers\BSP\Components\Common;..\STM32Cube_FW_F0_V1.2.0\Utilities\Log;..\STM32Cube_FW_F0_V1.2.0\Utilities\CPU;..\STM32Cube_FW_F0_V1.2.0\Drivers\CMSIS\Include;..\STM32Cube_FW_F4_V1.5.0\Middlewares\ST\STM32_Audio\Addons\PDM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Startup
    ./: startup_stm32f030x8.s
  group Main
    ./Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/CMSIS
    ./Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../STM32Cube_FW_F0_V1.2.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_spi.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c
  group libPDMFilter
    ../STM32Cube_FW_F4_V1.5.0/Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM0_Keil.lib
  group Scanner
    ./Src/: scanner.c
  group Decoder
    ./Src/: decoder.c
    ./Src/decoder/: ean.c
